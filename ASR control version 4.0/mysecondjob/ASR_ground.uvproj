# Keil uVision project ASR_ground.uvproj, settings and files
target ASR_ground (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ASR_ground
  AfterMake: fromelf.exe  --bin -o ./obj/ASR_ground.bin ./obj/ASR_ground.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\library\inc\
  memory RVCT4: ROM 0x8003000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group library
    ./library/src/: stm32f10x_lib.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_systick.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_nvic.c
  group interrupt
    ./interrupt/: stm32f10x_it.c
  group src
    ./src/: main.c
  group boot
    ./boot/: cortexm3_macro.s stm32f10x_vector.s
  group sd
    ./library/src/: sdcmd.c sdcrc.c sddriver.c sdhal.c msd.c
  group iap
    ./library/src/: flash operation.c
