# Keil uVision project sdtest.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sdtest
  c flags: Optim=1
  c include: .
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group 1
    ./: sdcmd.c sdcrc.c sddriver.c sdhal.c cortexm3_macro.s stm32f10x_vector.s
    ./SD/SD_card/code/driver/: msd.c uart.c
    ./SD/SD_card/code/library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim1.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./SD/SD_card/code/system/: stm32f10x_it.c
    ./SD/SD_card/code/user/: main.c
