# Keil uVision project myfirstjob.uvproj, settings and files
target ASR_Rocket (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: myfirstjob +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\library\inc\
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group library
    ./library/src/: stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_usart.c stm32f10x_systick.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_tim.c
  group boot
    ./boot/: stm32f10x_vector.s cortexm3_macro.s
  group interrupt
    ./interrupt/: stm32f10x_it.c
  group src
    ./src/: main.c
  group sd-library
    ./library/src/: sdcmd.c sdcrc.c sddriver.c sdhal.c msd.c
