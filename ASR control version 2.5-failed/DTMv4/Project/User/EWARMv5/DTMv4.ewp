# IAR project DTMv4.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Core\CM3\; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: DTMv4.hex
  ILINK.IlinkOutputFile: DTMv4.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Core\CM3; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: STM3210B-EVAL.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  group CMSIS
    ../../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group Doc
    ./: readme.txt
  group EWARMv5
    ../../../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../: applications.h hardware.h main.c platform.h stm32f10x_it.c
  group User/global
    ../global/: delay.c systick.c vtimer.c
  group User/HAL
    ../HAL/: ads1256.c Minikit.c STM32_ADC.c uart1.c
  group User/Lib/FATFS
    ../Lib/fatfs/: diskio.h fattime.c fattime.h ff.c ff.h ffconf.h integer.h sd_spi_stm32.c
